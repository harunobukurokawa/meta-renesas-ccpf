RDEPENDS_perf-tests:append = " bash"
